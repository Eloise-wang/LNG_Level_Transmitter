# Keil uVision project Project.uvproj, settings and files
target W25Q16 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: HZK16 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\Startup;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\inc;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\src;..\User\Main;..\User\Delay;..\User\Led;..\User\W25Q16;..\User\PCAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User/Main
    ../User/Main/: main.c stm32f10x_it.c hw_config.c
    ../User/Public/Common/: Common.c
  group Libraries/StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c
  group Libraries/CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
  group Main/W25Q16
    ../User/W25Q16/: w25q16.c
  group Doc
    ../Doc/: information.txt
  group Main/PCAP
    ../User/PCAP/: PCAP.C
